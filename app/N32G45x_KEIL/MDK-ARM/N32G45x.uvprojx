# Keil uVision project N32G45x.uvprojx, settings and files
target N32G45x (6160000::V6.16::ARMCLANG)
  device: N32G452VEL7 Nationstech
  pack: Nationstech.N32G45x_DFP.1.3.0
  cpu: IRAM(0x20000000,0x24000) IROM(0x08010000,0x2F000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: N32G45x +hex
  AfterMake: cmd /c ""E:\Keil_v5\ARM\ARMCLANG\Bin\fromelf.exe" --bin --output=.\Objects\@L.bin !L && "E:\Keil_v5\ARM\ARMCLANG\Bin\fromelf.exe" --i32 --output=.\Objects\@L.hex !L"
  AfterMake: ..\..\..\tool\tool.exe -p n32
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: N32G45X, USE_STDPERIPH_DRIVER, VECT_TAB_OFFSET=0x00010000
  c include: ..\Core\inc;..\Core\src;..\Drivers\CMSIS\core;..\Drivers\CMSIS\device;..\Drivers\CMSIS\device\startup;..\Drivers\N32G45X_HAL_Drivers\inc;..\Drivers\N32G45X_HAL_Drivers\src;..\User_Src;..\User_Src\Self_Driver;..\User_Src\Middle;..\User_Src\App;..\User_Src\Driver;..\User_Src\HSI_afe;..\User_Src\SOX;..\User_Src\Protocol;..\User_Src\Protocol\UDS\UDSBase;..\User_Src\Protocol\UDS\UDSLogic;..\User_Src\RTT;..\Middlewares\Third_Party\FreeRTOS\Source\include;..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS;..\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM4F
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0x2f000
  memory RVCT9: RAM 0x20000000 size 0x24000
  group User
    ../Core/src/: main.c n32g45x_it.c
  group Driver/n32g45x_std_driver
    ../Drivers/N32G45X_HAL_Drivers/src/: misc.c n32g45x_tim.c n32g45x_usart.c n32g45x_adc.c n32g45x_exti.c n32g45x_flash.c n32g45x_gpio.c n32g45x_iwdg.c n32g45x_rcc.c n32g45x_rtc.c n32g45x_bkp.c n32g45x_can.c n32g45x_spi.c n32g45x_pwr.c n32g45x_wwdg.c
  group Driver/CMSIS
    ../Drivers/CMSIS/device/: system_n32g45x.c
    ../Drivers/CMSIS/device/startup/: startup_n32g45x.s
  group Driver
    ../User_Src/Driver/: d_uart.c d_uart.h d_timer.c d_timer.h d_gpio.c d_gpio.h d_exti.c d_exti.h d_flash.c d_flash.h d_rtc.c d_rtc.h d_system.c d_system.h d_watchdog.c d_watchdog.h d_adc.c d_adc.h d_flash_spi.c d_flash_spi.h d_can.c d_can.h
  group User/Middle
    ../User_Src/Middle/: m_circular_buf.c m_circular_buf.h m_delay.c m_delay.h m_soft_i2c.c m_soft_i2c.h m_flash_wl.c m_flash_wl.h
  group User/Board
    ../User_Src/Board/: board_io.c board_io.h board_power_port.c board_power_port.h
  group Task
    ../User_Src/task/: app_freertos.c app_freertos.h bms_task.c bms_task.h afe_task.c afe_task.h comm_task.c comm_task.h data_handle_task.c data_handle_task.h save_log_task.c save_log_task.h default_task.c default_task.h stack_monitor_task.c stack_monitor_task.h
  group User_Src/App
    ../User_Src/App/: app_bms_fault.c app_bms_fault.h app_bms_fault_config.h app_bms_fault_config_validate.h app_flash_map.h app_param.c app_param.h app_param_api.h app_param_validate.h app_h_power_manage.c app_h_power_manage.h app_power_manage.c app_power_manage.h app_long_time_undervoltage_shutdown.c app_long_time_undervoltage_shutdown.h app_log_manage.c app_log_manage.h app_current_calib.c app_current_calib.h app_bms_obc.c app_bms_snapshot.c app_bms_status.c app_bms_status.h app_charge_time.c app_charge_time.h app_bms_obc.h app_bms_snapshot.h app_bms_types.h app_cell_topology.h app_balance_manage.c app_balance_manage.h app_hw_apply.c app_hw_apply.h app_low_power_manage.c app_low_power_manage.h app_mcu_ntc.c app_mcu_ntc.h app_input_signals.c app_input_signals.h app_led.c app_led.h app_can.c app_can.h
  group User/SOX
    ../User_Src/SOX/: app_soc.c app_soc.h app_sop.c app_sop.h
  group User/Protocol/IAP
    ../User_Src/Protocol/IAP/: ducar_can_iap_protocol.c ducar_can_iap_protocol.h ducar_uart_iap_protocol.c ducar_uart_iap_protocol.h
  group User/Protocol/Comm
    ../User_Src/Protocol/Comm/: zs_b1_can_protocol.c zs_b1_can_protocol.h ducar_can_protocol.c ducar_can_protocol.h ducar_uart_protocol.c ducar_uart_protocol.h
  group User/Protocol/UDS
    ../User_Src/Protocol/UDS/UDSBase/: uds_port.c uds_port.h uds_service.c uds_service.h uds_tp_private.h uds_tp.c uds_tp.h uds_type.h
    ../User_Src/Protocol/UDS/UDSLogic/: service_cfg.c service_cfg.h SID10_SessionControl.c SID10_SessionControl.h SID11_EcuReset.c SID11_EcuReset.h SID14_ClearDiagnosticInformation.c SID14_ClearDiagnosticInformation.h SID19_ReadDTCInformation.c SID19_ReadDTCInformation.h SID22_ReadDataByIdentifier.c SID22_ReadDataByIdentifier.h SID27_SecurityAccess.c SID27_SecurityAccess.h SID28_CommunicationControl.c SID28_CommunicationControl.h SID2E_WriteDataByIdentifier.c SID2E_WriteDataByIdentifier.h SID31_RoutineControl.c SID31_RoutineControl.h SID34_RequestDownload.c SID34_RequestDownload.h SID36_TransferData.c SID36_TransferData.h SID37_RequestTransferExit.c SID37_RequestTransferExit.h uds_upgrade.c uds_customer_profile.c SID3E_TesterPresent.c SID3E_TesterPresent.h SID85_ControlDTCSetting.c SID85_ControlDTCSetting.h
  group User/HSI_afe
    ../User_Src/HSI_afe/: hsi_afe.c hsi_afe.h hsi_afe_dvc1124.c hsi_afe_dvc1124.h hsi_ntc.c hsi_ntc.h
  group RTT
    ../User_Src/RTT/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Conf.h SEGGER_RTT_printf.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
