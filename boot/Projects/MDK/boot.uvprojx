# Keil uVision project boot.uvprojx, settings and files
target boot (6160000::V6.16::ARMCLANG)
  device: N32G452VEL7 Nationstech
  pack: Nationstech.N32G45x_DFP.1.3.0
  cpu: IRAM(0x20000000,0x24000) IROM(0x08000000,0xF800) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: boot +hex
  AfterMake: cmd /c ""E:\Keil_v5\ARM\ARMCLANG\Bin\fromelf.exe" --bin --output=.\Objects\@L.bin !L && "E:\Keil_v5\ARM\ARMCLANG\Bin\fromelf.exe" --i32 --output=.\Objects\@L.hex !L"
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: N32G45X, USE_STDPERIPH_DRIVER
  c include: ..\..\Core\inc;..\..\Core\src;..\..\Drivers\CMSIS\core;..\..\Drivers\CMSIS\device;..\..\Drivers\CMSIS\device\startup;..\..\Drivers\N32G45X_HAL_Drivers\inc;..\..\Drivers\N32G45X_HAL_Drivers\src;..\..\User;..\..\User\Boot;..\..\User\Hal_Driver;..\..\User\Protocol;..\..\User\UDS\UDSLogic;..\..\User\UDS\UDSBase;..\..\..\app\N32G45x_KEIL\User_Src\Protocol\UDS\UDSLogic;..\..\..\app\N32G45x_KEIL\User_Src\App;..\..\RTT
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0xf800
  memory RVCT9: RAM 0x20000000 size 0x24000
  group User
    ../../Core/src/: main.c n32g45x_it.c
    ../../Core/inc/: main.h n32g45x_it.h
  group User/Boot
    ../../User/Boot/: boot_config.h boot_manage.c boot_manage.h boot_app.c boot_app.h boot_upgrade.c boot_upgrade.h boot_protocol.c boot_protocol.h boot_can_upgrade.c boot_can_upgrade.h
  group User/Hal_Driver
    ../../User/Hal_Driver/: boot_timer.c boot_timer.h boot_uart.c boot_uart.h boot_flash.c boot_flash.h boot_crc.c boot_crc.h boot_watchdog.c boot_watchdog.h boot_led.c boot_led.h boot_can.c boot_can.h
  group Driver/n32g45x_std_driver
    ../../Drivers/N32G45X_HAL_Drivers/src/: misc.c n32g45x_tim.c n32g45x_usart.c n32g45x_flash.c n32g45x_iwdg.c n32g45x_gpio.c n32g45x_rcc.c n32g45x_can.c
  group Driver/CMSIS
    ../../Drivers/CMSIS/device/: system_n32g45x.c
    ../../Drivers/CMSIS/device/startup/: startup_n32g45x.s
  group RTT
    ../../RTT/: SEGGER_RTT.c SEGGER_RTT_Conf.h SEGGER_RTT_printf.c SEGGER_RTT.h
  group User/Protocol/IAP
    ../../User/Protocol/: ducar_iap_protocol.c ducar_iap_protocol.h ducar_can_protocol.c ducar_can_protocol.h
  group User/UDS
    ../../User/UDS/UDSBase/: uds_port.c uds_tp.c uds_service.c uds_port.h uds_service.h uds_tp.h uds_tp_private.h
    ../../User/UDS/UDSLogic/: service_cfg.c SID10_SessionControl.c SID22_ReadDataByIdentifier.c boot_uds_support.c uds_upgrade.c boot_uds.c service_cfg.h uds_upgrade.h
    ../../../app/N32G45x_KEIL/User_Src/Protocol/UDS/UDSLogic/: SID11_EcuReset.c SID27_SecurityAccess.c SID2E_WriteDataByIdentifier.c SID31_RoutineControl.c SID34_RequestDownload.c SID36_TransferData.c SID37_RequestTransferExit.c SID3E_TesterPresent.c uds_customer_profile.c
